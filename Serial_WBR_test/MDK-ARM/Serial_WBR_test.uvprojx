# Keil uVision project Serial_WBR_test.uvprojx, settings and files
target Serial_WBR_test (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Serial_WBR_test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;../IFR_LIB-V4.0;../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Drivers/CMSIS/DSP/Include;../Middlewares/ST/ARM/DSP/Inc;../IMU
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c can.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group IFR_LIB-V4.0
    ../IFR_LIB-V4.0/: ifr_can.cpp ifr_crc.c ifr_dmmotor.cpp ifr_fdcan.cpp ifr_gpio.cpp ifr_key.cpp ifr_motor.cpp ifr_pid.cpp ifr_pwm.cpp ifr_remote.c ifr_robstride.cpp ifr_state_machine.cpp ifr_tim.cpp ifr_usart.cpp
  group Core
    ../Core/Src/: Chassis_output.cpp Chassis_Controller.cpp VOFA_Justfloat_Transmit.cpp VMC_Cal.cpp LQR_Cal.cpp
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Middlewares/Library/DSP Library/DSP Library
    ../Drivers/CMSIS/DSP/Source/FastMathFunctions/: arm_atan2_f32.c
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM4lf_math.lib
  group IMU
    ../IMU/: bmi088.cpp
software components: CMSIS:CORE 4.3.0
